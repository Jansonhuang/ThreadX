# Keil uVision project LPC2106.uvproj, settings and files
target LPC2106 (ARM-ADS)
  device: LPC2106 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x4000FFFF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: LPC2106 +hex
  c flags: Optim=1 wLevel=1
  c misc: -Ono_fp_formats
  c include: ..\include;..\threadx
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x40000000 size 0x10000
  link misc: --first start.o(INT_CODE)
  group board
    ../board/LPC2106/: LPC2106.c
  group cpu
    ../cpu/LPC21xx/: start.s cpu.c Int_c.c interrupts.c Int.s tx_tsr.s tx_tcr.s tx_tcs.s tx_tpc.s tx_ts.s tx_tsb.c tx_ill.c tx_tic.c tx_timin.c
  group lib_arm
    ../lib_arm/: rt_sys.c
  group lib_generic
    ../lib_generic/: generic.c application.c
  group threadx
    ../threadx/: threadx.lib
